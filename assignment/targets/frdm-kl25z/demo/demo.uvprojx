# Keil uVision project demo.uvprojx, settings and files
target ML Supervised demo (6210000::V6.21::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement -Wno-date-time -Wno-class-varargs -Wno-format-nonliteral -Wno-unsafe-buffer-usage
  c include: .\bsp;.\bsp\delay;.\bsp\mma8451;.\bsp\queue;.\bsp\rgb;.\bsp\uart0;.\temperature;.\..\..\..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group bsp
    ./bsp/: bsp.h
  group bsp\delay
    ./bsp/delay/: delay.c delay.h
  group bsp\mma8451
    ./bsp/mma8451/: i2c0.c i2c0.h mma8451.c mma8451.h
  group bsp\queue
    ./bsp/queue/: queue.c queue.h
  group bsp\rgb
    ./bsp/rgb/: rgb.c rgb.h
  group bsp\uart0
    ./bsp/uart0/: uart0.c uart0.h
  group temperature
    ./temperature/: temp.c temp.h
  group lib
    ../../../lib/: features.c features.h filters.c filters.h normalizations.c normalizations.h
  group src
    ./src/: main.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.5.0
